# Keil uVision project DEMO_project.uvprojx, settings and files
target uart (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO_project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10XMD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\ANO;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\HARDWARE;..\HARDWARE\STMFLASH;..\HARDWARE\parameter;..\HARDWARE\Init;..\HARDWARE\Exti;..\HARDWARE\PS2;..\HARDWARE\MOTOR;..\HARDWARE\USART2;..\HARDWARE\CONTROL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/ANO/: ANO.c
    ../HARDWARE/NRF24L01/: ANO_Drv_Nrf24l01.c
    ../HARDWARE/SPI/: ANO_Drv_SPI.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/parameter/: Parameter.c
    ../HARDWARE/Init/: Init.c
    ../HARDWARE/Exti/: exti.c
    ../HARDWARE/PS2/: pstwo.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/CONTROL/: control.c
